options:
  parameters:
    author: javier
    generate_options: qt_gui
    id: A2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_offset
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: psk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: channels_phase_noise_gen_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: '0.5'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: psk
    differential: 'True'
    excess_bw: '1'
    samples_per_symbol: sps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: pll_sdrpll_0
  id: pll_sdrpll
  parameters:
    a2: '0'
    a3: '0'
    b3: '0'
    bw_hz: '10'
    custom_params: 'False'
    detector_type: '2'
    filt_order: '2'
    k_d: '1'
    k_o: '1'
    nco_base_freq_hz: samp_rate*freq_offset
    period: 1/samp_rate
    w0: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_throttle_0, '0', pll_sdrpll_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', channels_phase_noise_gen_0, '0']
- [channels_phase_noise_gen_0, '0', blocks_throttle_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [pll_sdrpll_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [pll_sdrpll_0, '0', qtgui_freq_sink_x_0, '1']
- [pll_sdrpll_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
