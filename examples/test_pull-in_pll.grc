options:
  parameters:
    author: Javier Arribas
    copyright: GPL v3 Public License
    generate_options: qt_gui
    id: AA
    output_language: python
    title: Test PLL pull-in transotory
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: '1400'
  states: {}
- name: pll_nco_freq
  id: variable
  parameters:
    value: '1400'
  states: {}
- name: pll_nco_freq_error
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '1400'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cmath.exp(1j*pi*90/180)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: pll_sdrpll_0
  id: pll_sdrpll
  parameters:
    a2: '0'
    a3: '0'
    b3: '0'
    bw_hz: '10'
    custom_params: 'False'
    detector_type: '1'
    filt_order: '3'
    k_d: '1'
    k_o: '1'
    nco_base_freq_hz: pll_nco_freq-pll_nco_freq_error
    period: 1/samp_rate
    w0: '0'
  states: {}
- name: pll_sdrpll_0_0
  id: pll_sdrpll
  parameters:
    a2: '0'
    a3: '0'
    b3: '0'
    bw_hz: '100'
    custom_params: 'False'
    detector_type: '1'
    filt_order: '2'
    k_d: '1'
    k_o: '1'
    nco_base_freq_hz: pll_nco_freq-pll_nco_freq_error
    period: 1/samp_rate
    w0: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Synchro
    label2: RX signal
    label3: 'PLL #1 output'
    label4: 'PLL #2 output'
    name: RX signal vs. PLL output
    nconnections: '4'
    size: 1024*4
    srate: samp_rate
    tr_delay: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    ctrlpanel: 'True'
    label1: Synchro
    label2: 'PLL #1 output'
    label3: 'PLL #2 output '
    name: '"Phase Error [deg]"'
    nconnections: '3'
    size: 1024*4
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.1'
    ylabel: '[deg]'
    ymax: '180'
    ymin: '-180'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_0, '0']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', pll_sdrpll_0, '0']
- [blocks_multiply_const_vxx_0, '0', pll_sdrpll_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', pll_sdrpll_0, '0']
- [blocks_throttle_0, '0', pll_sdrpll_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']
- [pll_sdrpll_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [pll_sdrpll_0, '0', qtgui_time_sink_x_0, '2']
- [pll_sdrpll_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [pll_sdrpll_0_0, '0', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
