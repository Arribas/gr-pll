options:
  parameters:
    author: javier
    generate_options: qt_gui
    id: A1
    output_language: python
    title: Test RTLSDR PLL FM RX
  states: {}

blocks:
- name: audio_filter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '10000'
    gain: '1.0'
    samp_rate: ch_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: audio_rate*5
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88e6
    step: 100e3
    stop: 108e6
    value: '98000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: tune_freq
  id: variable
  parameters:
    value: rx_freq - samp_rate/4
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.2'
    type: float
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/75000
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-pi/2'
  states: {}
- name: fft_filter_xxx_1_0
  id: fft_filter_xxx
  parameters:
    decim: int(ch_rate/audio_rate)
    taps: audio_filter
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: pfb_decimator_ccf_1
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: int(samp_rate/ch_rate)
    taps: ()
  states: {}
- name: pll_sdrpll_0
  id: pll_sdrpll
  parameters:
    a2: '0.0'
    a3: '0.0'
    b3: '0.0'
    bw_hz: '75000'
    custom_params: 'False'
    detector_type: '1'
    filt_order: '2'
    k_d: '1'
    k_o: '1'
    nco_base_freq_hz: '0'
    period: 1/ch_rate
    w0: '1.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: ch_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: RX Signal
    label2: PLL Recovered signal
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.8'
    average: '0.2'
    bw: audio_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,2,2,1
    legend: 'False'
    name: Demodulated audio Spectrum
    showports: 'True'
    type: float
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '20'
    ymin: '-80'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: tune_freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', audio_sink_0_0_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', fft_filter_xxx_1_0, '0']
- [blocks_rotator_cc_0, '0', pfb_decimator_ccf_1, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [fft_filter_xxx_1_0, '0', analog_agc_xx_0, '0']
- [pfb_decimator_ccf_1, '0', pll_sdrpll_0, '0']
- [pfb_decimator_ccf_1, '0', qtgui_freq_sink_x_0, '0']
- [pll_sdrpll_0, '0', qtgui_freq_sink_x_0, '1']
- [pll_sdrpll_0, '1', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
